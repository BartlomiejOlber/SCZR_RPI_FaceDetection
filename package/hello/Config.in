## package/hello/Config.in
```kconfig
config BR2_PACKAGE_HELLO
	bool "hello"
	help
	  Hello world opencv-using package

	  http://lfc.pl
```
